# Keil uVision project usb_keyb.uvprojx, settings and files
target usb_keyb (6040000::V6.4::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: usb_keyb +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-c++98-compat -Wno-c++98-compat-pedantic -Wno-padded -Wno-undef -Wno-packed -Wno-sign-conversion -Wno-conversion -Wno-missing-noreturn -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-unused-parameter -Wno-unused-function -Wno-covered-switch-default -Wno-switch-enum
  c include: ../Inc;                         ../Drivers/STM32F4xx_HAL_Driver/Inc;                         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                         ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;                         ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;                         ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc;                         ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;                         ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;                         ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;                         ../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Inc;                         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                         ../Middlewares/Third_Party/FatFs/src;                         ../Middlewares/Third_Party/FreeRTOS/Source/include;                         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                         ../Drivers/CMSIS/Include;                         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;             ../Middlewares/Third_Party/LwIP/src/include;             ../Middlewares/Third_Party/LwIP/system;             ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;             ../Middlewares/Third_Party/LwIP/src/include/lwip;             ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;             ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;             ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;             ../Middlewares/Third_Party/LwIP/src/include/netif;             ../Middlewares/Third_Party/LwIP/src/include/posix;             ../Middlewares/Third_Party/LwIP/src/include/posix/sys;             ../Middlewares/Third_Party/LwIP/system/arch
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User
    ../Src/: usbh_diskio.c fatfs.c stm32f4xx_hal_msp.c usb_host.c main.c stm32f4xx_hal_timebase_TIM.c freertos.c bsp_driver_sd.c usbh_conf.c usbh_platform.c sd_diskio.c stm32f4xx_it.c gui_all.c lcd_driver.c AsciiLib.c kbd_matrix.c ethernetif.c lwip.c fatfs_platform.c fw_updater.c ps2.c ringbuffer.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_parser.c usbh_hid_mouse.c usbh_hid.c usbh_hid_keybd.c
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ctlreq.c usbh_core.c usbh_ioreq.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c croutine.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_uart.c stm32f4xx_hal_eth.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c dhcp.c ip4_frag.c igmp.c icmp.c autoip.c etharp.c ip4.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppoe.c pppcrypt.c pppapi.c vj.c magic.c mppe.c pppol2tp.c ipcp.c chap-new.c fsm.c utils.c demand.c eui64.c lcp.c ipv6cp.c ppp.c chap_ms.c pppos.c eap.c ecp.c ccp.c chap-md5.c auth.c multilink.c upap.c
    ../Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netifapi.c err.c api_msg.c netdb.c netbuf.c api_lib.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: nd6.c inet6.c mld6.c icmp6.c dhcp6.c ip6_frag.c ethip6.c ip6_addr.c ip6.c
    ../Middlewares/Third_Party/LwIP/src/core/: timeouts.c netif.c udp.c mem.c dns.c tcp_in.c ip.c memp.c sys.c init.c def.c raw.c tcp.c tcp_out.c inet_chksum.c pbuf.c stats.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
software components: CMSIS:CORE 4.3.0

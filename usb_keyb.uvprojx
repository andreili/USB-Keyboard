# Keil uVision project usb_keyb.uvprojx, settings and files
target Target 1 (6040000::V6.4::.\ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_keyb +hex
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__GNUC__
  c include: .\inc;.\libs\CMSIS\Device\ST\STM32F4xx\Include;.\libs\CMSIS\Include;.\libs\STM32F4xx_StdPeriph_Driver\inc;.\libs\STM32_USB_HOST_Library\Core\inc;.\libs\STM32_USB_HOST_Library\Class\HID\inc;.\libs\STM32_USB_OTG_Driver\inc;.\libs\fat_fs\inc;.\libs\STM32_USB_HOST_Library\Class\MSC\inc;.\libs\STM32_USB_Device_Library\Class\msc\inc;.\libs\STM32_USB_Device_Library\Core\inc;.\libs\uCGUI_LIB\GLCD;.\libs\uCGUI_LIB\uCGUI\Core;.\libs\uCGUI_LIB\uCGUI\WM;.\libs\uCGUI_LIB\uCGUI\Config;.\libs\uCGUI_LIB\uCGUI\Widget;.\libs\FreeRTOS\include;.\libs\FreeRTOS\CMSIS_RTOS;.\libs\FreeRTOS\portable\RVDS\ARM_CM4F;.\libs\MakiseGUI;.\libs\MakiseGUI\fonts;.\libs\MakiseGUI\gui;.\libs\MakiseGUI\gui\styles;.\libs\MakiseGUI\gui\elements;.\libs\MakiseGUI\gui\elements\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: main.c stm32fxxx_it.c usb_bsp.c hid_proc.c ms_proc.c kbd_matrix.c gui_all.c lcd_driver.c AsciiLib.c
    ./inc/: FreeRTOSConfig.h
  group USB_Host
    ./libs/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./libs/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c
    ./libs/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_hcd.c usb_core.c
    ./libs/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_fatfs.c usbh_msc_core.c usbh_msc_bot.c usbh_msc_scsi.c
  group StdPeriph
    ./libs/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group System
    ./src/: system_stm32f4xx.c
    ./libs/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group FatFS
    ./libs/fat_fs/src/: fattime.c ff.c
  group FreeRTOS
    ./libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ./libs/FreeRTOS/portable/MemMang/: heap_4.c
    ./libs/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
